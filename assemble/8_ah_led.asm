PORTPIN EQU P1.0
CSEG AT 0
;ACALL DELAY_1mS
MOV R7,0X00
LOOP :
MOV P2,R7
INC R7
ACALL DELAY_1S
CJNE R7,#0x00,LOOP
SJMP $
DELAY_1MS:
MOV R0,#255
DJNZ R0,$
MOV R0,#244
DJNZ R0,$
RET
DELAY_10MS:
MOV R1,#9
L1:ACALL DELAY_1MS
DJNZ R1,L1
MOV R1,#255
DJNZ R1,$
MOV R1,#214
DJNZ R1,$
NOP
RET
DELAY_100MS:
MOV R2,#9
L2:ACALL DELAY_10MS
DJNZ R2,L2
MOV R2,#9
L3:ACALL DELAY_1MS
DJNZ R2,L3
MOV R2,#255
DJNZ R2,$
MOV R2,#205
DJNZ R2,$
RET
DELAY_1S:
MOV R3,#9
L4:ACALL DELAY_100MS
DJNZ R3,L4
MOV R3,#99
L5:ACALL DELAY_1MS
DJNZ R3,L5
MOV R3,#190
DJNZ R3,$
NOP
RET
END